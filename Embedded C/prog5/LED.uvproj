# Keil uVision project LED.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: LED
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: led1.c led2.c led3.c led4.c led5.c led6.c led7.c
