# Keil uVision project interrupts.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: interrupts
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: interrupt1.asm interrupt2.asm interrupt3.asm interupt4.asm
